# Keil uVision project IOT_Code.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IOT_Code +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\lib\inc;..\project;..\source;..\source\uart;..\source\delay;..\source\can;..\source\laser_l1;..\source\timer;..\source\iot;..\source\led;..\source\key;..\source\rj45;..\source\wifi;..\source\power;..\source\charge
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group project
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../source/rj45/: rj45.c
  group source
    ../source/uart/: usart1.c usart2.c usart3.c uart5.c uart4.c
    ../source/delay/: delay.c
    ../source/iot/: iot_io.c iot.c
    ../source/can/: can.c
    ../source/laser_l1/: laser.c
    ../source/timer/: timer4.c
    ../source/led/: led.c
    ../source/key/: key.c
    ../source/rj45/: rj45.c
    ../source/wifi/: wifi.c
    ../source/power/: power.c
    ../source/charge/: charge.c
